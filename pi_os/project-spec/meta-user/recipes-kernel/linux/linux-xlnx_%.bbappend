SRC_URI += "file://zynqberry.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
